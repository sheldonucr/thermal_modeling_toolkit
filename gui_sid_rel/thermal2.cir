** Original thermal ckt realization

C1 1 0 1.000000000000000e-06
C2 2 0 1.000000000000000e-06
C3 3 0 -1.000000000000000e-06
C4 4 0 1.000000000000000e-06
C5 5 0 1.000000000000000e-06
R1 2 3 3.158227030149767e+05
R2 1 0 3.780880605715709e+04
R3 2 0 1.962757683722967e+05
R4 3 0 -8.750790221383506e+04
R5 4 0 8.589297001492558e+05
R6 5 0 4.383802605081942e+07
V_ex_1 o_port_1 port_1 0
F_1_1 1 0 V_ex_1 -3.063483851013932e-10
F_2_1 2 0 V_ex_1 7.726498534186199e-11
F_3_1 3 0 V_ex_1 1.671695105847403e-10
F_4_1 4 0 V_ex_1 3.918983180423250e-13
F_5_1 5 0 V_ex_1 9.635422565482414e-16
E_1_1 o_port_1 n_1_1 1 0 4.587256600503409e-02
E_2_1 n_1_1 n_2_1 2 0 -7.492422620586581e-03
E_3_1 n_2_1 n_3_1 3 0 -3.198828011476695e-02
E_4_1 n_3_1 n_4_1 4 0 1.324999609383478e+00
E_5_1 n_4_1 0 5 0 6.930205867961558e+01
E_1_2 o_port_2 n_1_2 1 0 4.805829195077038e-02
E_2_2 n_1_2 n_2_2 2 0 -3.011332266218325e-02
E_3_2 n_2_2 n_3_2 3 0 -4.739213470327130e-02
E_4_2 n_3_2 n_4_2 4 0 1.424163920666569e+00
E_5_2 n_4_2 0 5 0 6.941451896131807e+01
E_1_3 o_port_3 n_1_3 1 0 4.030827505785339e-02
E_2_3 n_1_3 n_2_3 2 0 -7.966136655499589e-02
E_3_3 n_2_3 n_3_3 3 0 -7.934340154815123e-02
E_4_3 n_3_3 n_4_3 4 0 1.538570330872099e+00
E_5_3 n_4_3 0 5 0 6.957925946254966e+01
E_1_4 o_port_4 n_1_4 1 0 -2.138478331244276e-01
E_2_4 n_1_4 n_2_4 2 0 -9.053677068099120e-02
E_3_4 n_2_4 n_3_4 3 0 -1.332234619633967e-01
E_4_4 n_3_4 n_4_4 4 0 1.766279207575549e+00
E_5_4 n_4_4 0 5 0 6.971784951523688e+01
E_1_5 o_port_5 n_1_5 1 0 -4.435111698575369e-01
E_2_5 n_1_5 n_2_5 2 0 -5.906885564149889e-02
E_3_5 n_2_5 n_3_5 3 0 -1.600877400584833e-01
E_4_5 n_3_5 n_4_5 4 0 1.927586661085521e+00
E_5_5 n_4_5 0 5 0 6.977235127027254e+01
E_1_6 o_port_6 n_1_6 1 0 3.884040256973265e-02
E_2_6 n_1_6 n_2_6 2 0 -4.093287912528609e-03
E_3_6 n_2_6 n_3_6 3 0 -3.055537687825527e-02
E_4_6 n_3_6 n_4_6 4 0 1.310760914372902e+00
E_5_6 n_4_6 0 5 0 6.934371949448267e+01
E_1_7 o_port_7 n_1_7 1 0 4.194876830094429e-02
E_2_7 n_1_7 n_2_7 2 0 -2.580769648793435e-02
E_3_7 n_2_7 n_3_7 3 0 -4.534908297988782e-02
E_4_7 n_3_7 n_4_7 4 0 1.412284282806444e+00
E_5_7 n_4_7 0 5 0 6.943370132633038e+01
E_1_8 o_port_8 n_1_8 1 0 3.914921063458365e-02
E_2_8 n_1_8 n_2_8 2 0 -7.240712359230983e-02
E_3_8 n_2_8 n_3_8 3 0 -7.516147718703037e-02
E_4_8 n_3_8 n_4_8 4 0 1.525334310872601e+00
E_5_8 n_4_8 0 5 0 6.956610563903311e+01
E_1_9 o_port_9 n_1_9 1 0 -9.638700312584003e-02
E_2_9 n_1_9 n_2_9 2 0 -1.003103413613289e-01
E_3_9 n_2_9 n_3_9 3 0 -1.166999837257172e-01
E_4_9 n_3_9 n_4_9 4 0 1.677740671482692e+00
E_5_9 n_4_9 0 5 0 6.966828439925999e+01
E_1_10 o_port_10 n_1_10 1 0 -2.146984038693214e-01
E_2_10 n_1_10 n_2_10 2 0 -8.920711313252294e-02
E_3_10 n_2_10 n_3_10 3 0 -1.331088022437628e-01
E_4_10 n_3_10 n_4_10 4 0 1.764899939972242e+00
E_5_10 n_4_10 0 5 0 6.971390920308602e+01
E_1_11 o_port_11 n_1_11 1 0 3.152607039029576e-02
E_2_11 n_1_11 n_2_11 2 0 4.464637895191359e-03
E_3_11 n_2_11 n_3_11 3 0 -2.508346935833994e-02
E_4_11 n_3_11 n_4_11 4 0 1.243731254743725e+00
E_5_11 n_4_11 0 5 0 6.933721563287520e+01
E_1_12 o_port_12 n_1_12 1 0 3.535293351557200e-02
E_2_12 n_1_12 n_2_12 2 0 -1.160372801875020e-02
E_3_12 n_2_12 n_3_12 3 0 -3.643782925000938e-02
E_4_12 n_3_12 n_4_12 4 0 1.345807301997043e+00
E_5_12 n_4_12 0 5 0 6.941342182824019e+01
E_1_13 o_port_13 n_1_13 1 0 4.041771956627294e-02
E_2_13 n_1_13 n_2_13 2 0 -4.293996894613450e-02
E_3_13 n_2_13 n_3_13 3 0 -5.700761977986368e-02
E_4_13 n_3_13 n_4_13 4 0 1.456709398634436e+00
E_5_13 n_4_13 0 5 0 6.950622810566114e+01
E_1_14 o_port_14 n_1_14 1 0 3.912150584499052e-02
E_2_14 n_1_14 n_2_14 2 0 -7.215817288670934e-02
E_3_14 n_2_14 n_3_14 3 0 -7.514853519013487e-02
E_4_14 n_3_14 n_4_14 4 0 1.525842990465527e+00
E_5_14 n_4_14 0 5 0 6.956596467481185e+01
E_1_15 o_port_15 n_1_15 1 0 4.018513610809293e-02
E_2_15 n_1_15 n_2_15 2 0 -7.945467889569890e-02
E_3_15 n_2_15 n_3_15 3 0 -7.934182055097505e-02
E_4_15 n_3_15 n_4_15 4 0 1.538493147377775e+00
E_5_15 n_4_15 0 5 0 6.957990132986700e+01
E_1_16 o_port_16 n_1_16 1 0 2.285136026035239e-02
E_2_16 n_1_16 n_2_16 2 0 1.620999780493904e-02
E_3_16 n_2_16 n_3_16 3 0 -1.668330853273736e-02
E_4_16 n_3_16 n_4_16 4 0 1.138544468366441e+00
E_5_16 n_4_16 0 5 0 6.928980895739863e+01
E_1_17 o_port_17 n_1_17 1 0 2.725393030969592e-02
E_2_17 n_1_17 n_2_17 2 0 6.350353042886780e-03
E_3_17 n_2_17 n_3_17 3 0 -2.411923014197681e-02
E_4_17 n_3_17 n_4_17 4 0 1.236947807852704e+00
E_5_17 n_4_17 0 5 0 6.935418281507287e+01
E_1_18 o_port_18 n_1_18 1 0 3.534341241202021e-02
E_2_18 n_1_18 n_2_18 2 0 -1.154083542071582e-02
E_3_18 n_2_18 n_3_18 3 0 -3.643926824732591e-02
E_4_18 n_3_18 n_4_18 4 0 1.345938773730576e+00
E_5_18 n_4_18 0 5 0 6.941331063795464e+01
E_1_19 o_port_19 n_1_19 1 0 4.192049573789447e-02
E_2_19 n_1_19 n_2_19 2 0 -2.573305554419747e-02
E_3_19 n_2_19 n_3_19 3 0 -4.534669424344684e-02
E_4_19 n_3_19 n_4_19 4 0 1.412343276077973e+00
E_5_19 n_4_19 0 5 0 6.943380395797487e+01
E_1_20 o_port_20 n_1_20 1 0 4.800128043962815e-02
E_2_20 n_1_20 n_2_20 2 0 -2.994547183340401e-02
E_3_20 n_2_20 n_3_20 3 0 -4.739541976132122e-02
E_4_20 n_3_20 n_4_20 4 0 1.424321056744495e+00
E_5_20 n_4_20 0 5 0 6.941484540017743e+01
E_1_21 o_port_21 n_1_21 1 0 9.986697613483031e-03
E_2_21 n_1_21 n_2_21 2 0 2.769590413324075e-02
E_3_21 n_2_21 n_3_21 3 0 -7.776993182795011e-03
E_4_21 n_3_21 n_4_21 4 0 1.011345579388212e+00
E_5_21 n_4_21 0 5 0 6.921807373410283e+01
E_1_22 o_port_22 n_1_22 1 0 2.284706423949601e-02
E_2_22 n_1_22 n_2_22 2 0 1.625203560660005e-02
E_3_22 n_2_22 n_3_22 3 0 -1.668076526124340e-02
E_4_22 n_3_22 n_4_22 4 0 1.138919097615565e+00
E_5_22 n_4_22 0 5 0 6.928942447322902e+01
E_1_23 o_port_23 n_1_23 1 0 3.153997109887463e-02
E_2_23 n_1_23 n_2_23 2 0 4.474325982458893e-03
E_3_23 n_2_23 n_3_23 3 0 -2.507903103224407e-02
E_4_23 n_3_23 n_4_23 4 0 1.243919386824893e+00
E_5_23 n_4_23 0 5 0 6.933640143485842e+01
E_1_24 o_port_24 n_1_24 1 0 3.880256954887606e-02
E_2_24 n_1_24 n_2_24 2 0 -4.136580850621741e-03
E_3_24 n_2_24 n_3_24 3 0 -3.055829582791669e-02
E_4_24 n_3_24 n_4_24 4 0 1.310569802932959e+00
E_5_24 n_4_24 0 5 0 6.934316410258340e+01
E_1_25 o_port_25 n_1_25 1 0 4.577236177693145e-02
E_2_25 n_1_25 n_2_25 2 0 -7.436777074287804e-03
E_3_25 n_2_25 n_3_25 3 0 -3.196661230216125e-02
E_4_25 n_3_25 n_4_25 4 0 1.324977584810384e+00
E_5_25 n_4_25 0 5 0 6.930239735589343e+01
I_ex1 0 port_1 AC 1 sin(0 1 1K)
.tran 0.1ms 10ms
.AC DEC  100  0.001 100
.options accurate=0 post=1
.END
