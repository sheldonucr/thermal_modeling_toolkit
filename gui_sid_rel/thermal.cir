** Original thermal ckt realization

C1 1 0 1.000000000000000e-06
C2 2 0 1.000000000000000e-06
C3 3 0 -1.000000000000000e-06
C4 4 0 1.000000000000000e-06
C5 5 0 1.000000000000000e-06
C6 6 0 1.000000000000000e-06
C7 7 0 -1.000000000000000e-06
C8 8 0 1.000000000000000e-06
C9 9 0 1.000000000000000e-06
C10 10 0 -1.000000000000000e-06
C11 11 0 1.000000000000000e-06
C12 12 0 1.000000000000000e-06
C13 13 0 1.000000000000000e-06
C14 14 0 1.000000000000000e-06
C15 15 0 -1.000000000000000e-06
C16 16 0 1.000000000000000e-06
R1 2 3 8.225807629140103e+04
R2 6 7 1.980621276174087e+05
R3 9 10 3.757766973046897e+05
R4 14 15 6.757805495196510e+05
R5 1 0 3.572225957357881e+04
R6 2 0 1.380592671704563e+07
R7 3 0 -4.100687515244786e+04
R8 4 0 6.711341894197265e+04
R9 5 0 8.590420323948032e+04
R10 6 0 4.788624361797532e+05
R11 7 0 -8.206054657796971e+04
R12 8 0 1.166728961921286e+05
R13 9 0 -6.889287938424203e+05
R14 10 0 -2.583457975433478e+05
R15 11 0 2.645459905890295e+08
R16 12 0 3.041280047996167e+07
R17 13 0 1.240257513974223e+06
R18 14 0 4.516878784273929e+05
R19 15 0 -1.932942809162631e+05
R20 16 0 3.294201716403880e+05
V_ex_1 o_port_1 port_1 0
F_1_1 1 0 V_ex_1 -1.121490216235826e-09
F_2_1 2 0 V_ex_1 -7.405986638157284e-12
F_3_1 3 0 V_ex_1 -1.537929033644641e-10
F_4_1 4 0 V_ex_1 -1.733969886901902e-10
F_5_1 5 0 V_ex_1 2.202845151594256e-10
F_6_1 6 0 V_ex_1 -8.014083611599873e-11
F_7_1 7 0 V_ex_1 8.258802736354226e-11
F_8_1 8 0 V_ex_1 -1.215254093591312e-11
F_9_1 9 0 V_ex_1 1.863210372866352e-11
F_10_1 10 0 V_ex_1 -2.491228581205770e-11
F_11_1 11 0 V_ex_1 -1.986613888481464e-14
F_12_1 12 0 V_ex_1 -1.727338060947161e-13
F_13_1 13 0 V_ex_1 -5.975031287957003e-13
F_14_1 14 0 V_ex_1 -1.899783237077710e-11
F_15_1 15 0 V_ex_1 3.068063781364300e-11
F_16_1 16 0 V_ex_1 -1.693662026407150e-12
E_1_1 o_port_1 n_1_1 1 0 3.804785100081060e-03
E_2_1 n_1_1 n_2_1 2 0 9.984779756881945e-04
E_3_1 n_2_1 n_3_1 3 0 -2.704750413080756e-03
E_4_1 n_3_1 n_4_1 4 0 -2.286174997175955e-03
E_5_1 n_4_1 n_5_1 5 0 2.475976854295184e-02
E_6_1 n_5_1 n_6_1 6 0 9.032154119981151e-04
E_7_1 n_6_1 n_7_1 7 0 9.681302314888091e-03
E_8_1 n_7_1 n_8_1 8 0 1.427742066432629e-03
E_9_1 n_8_1 n_9_1 9 0 1.772047538049493e-04
E_10_1 n_9_1 n_10_1 10 0 4.631650294554921e-04
E_11_1 n_10_1 n_11_1 11 0 -6.999534656556372e-01
E_12_1 n_11_1 n_12_1 12 0 -3.127890174447496e-01
E_13_1 n_12_1 n_13_1 13 0 -3.986046685647516e-01
E_14_1 n_13_1 n_14_1 14 0 -3.874037912169970e-02
E_15_1 n_14_1 n_15_1 15 0 4.307538356195139e-02
E_16_1 n_15_1 0 16 0 2.468682315719612e-02
E_1_2 o_port_2 n_1_2 1 0 3.095471420943158e-03
E_2_2 n_1_2 n_2_2 2 0 4.232465431164290e-05
E_3_2 n_2_2 n_3_2 3 0 -7.956288510694576e-04
E_4_2 n_3_2 n_4_2 4 0 -1.070105820296291e-03
E_5_2 n_4_2 n_5_2 5 0 2.728033266211191e-02
E_6_2 n_5_2 n_6_2 6 0 -5.604050275339945e-03
E_7_2 n_6_2 n_7_2 7 0 9.389235052767536e-03
E_8_2 n_7_2 n_8_2 8 0 -4.615358388487707e-04
E_9_2 n_8_2 n_9_2 9 0 -1.431115486173612e-03
E_10_2 n_9_2 n_10_2 10 0 1.417081166137643e-03
E_11_2 n_10_2 n_11_2 11 0 -6.998976231962045e-01
E_12_2 n_11_2 n_12_2 12 0 -3.120379074429982e-01
E_13_2 n_12_2 n_13_2 13 0 -4.237260659970113e-01
E_14_2 n_13_2 n_14_2 14 0 -5.687773466296706e-02
E_15_2 n_14_2 n_15_2 15 0 4.987706313953640e-02
E_16_2 n_15_2 0 16 0 3.734246200358514e-02
E_1_3 o_port_3 n_1_3 1 0 -5.994502810500235e-03
E_2_3 n_1_3 n_2_3 2 0 1.723591960497983e-03
E_3_3 n_2_3 n_3_3 3 0 2.428055125107020e-03
E_4_3 n_3_3 n_4_3 4 0 7.795374023044310e-03
E_5_3 n_4_3 n_5_3 5 0 2.257351977369504e-02
E_6_3 n_5_3 n_6_3 6 0 -2.329815096122195e-02
E_7_3 n_6_3 n_7_3 7 0 -1.006913523787484e-03
E_8_3 n_7_3 n_8_3 8 0 2.916911339341660e-04
E_9_3 n_8_3 n_9_3 9 0 -2.639192315298078e-03
E_10_3 n_9_3 n_10_3 10 0 3.098533417956439e-03
E_11_3 n_10_3 n_11_3 11 0 -6.967629800209458e-01
E_12_3 n_11_3 n_12_3 12 0 -3.080137598331898e-01
E_13_3 n_12_3 n_13_3 13 0 -4.651125960636764e-01
E_14_3 n_13_3 n_14_3 14 0 -9.247793790287084e-02
E_15_3 n_14_3 n_15_3 15 0 5.188205796555082e-02
E_16_3 n_15_3 0 16 0 6.411716094531947e-02
E_1_4 o_port_4 n_1_4 1 0 -9.960445957471031e-02
E_2_4 n_1_4 n_2_4 2 0 8.732087645384323e-02
E_3_4 n_2_4 n_3_4 3 0 -2.586593089776223e-02
E_4_4 n_3_4 n_4_4 4 0 9.000142894657093e-02
E_5_4 n_4_4 n_5_4 5 0 7.648389620571905e-03
E_6_4 n_5_4 n_6_4 6 0 -4.132863545402410e-02
E_7_4 n_6_4 n_7_4 7 0 -9.885231186517462e-02
E_8_4 n_7_4 n_8_4 8 0 9.001970474092069e-04
E_9_4 n_8_4 n_9_4 9 0 -5.097014048385251e-03
E_10_4 n_9_4 n_10_4 10 0 7.424061691175900e-03
E_11_4 n_10_4 n_11_4 11 0 -6.803943498747510e-01
E_12_4 n_11_4 n_12_4 12 0 -2.909183114511784e-01
E_13_4 n_12_4 n_13_4 13 0 -5.400313896778870e-01
E_14_4 n_13_4 n_14_4 14 0 -1.871872582412927e-01
E_15_4 n_14_4 n_15_4 15 0 1.816251934279567e-02
E_16_4 n_15_4 0 16 0 1.453819446961382e-01
E_1_5 o_port_5 n_1_5 1 0 -1.791492636806802e-01
E_2_5 n_1_5 n_2_5 2 0 1.677276548253277e-01
E_3_5 n_2_5 n_3_5 3 0 -5.607194359909129e-02
E_4_5 n_3_5 n_4_5 4 0 1.594247792075778e-01
E_5_5 n_4_5 n_5_5 5 0 2.478424832959902e-03
E_6_5 n_5_5 n_6_5 6 0 -4.040188112295917e-02
E_7_5 n_6_5 n_7_5 7 0 -1.799833322956453e-01
E_8_5 n_7_5 n_8_5 8 0 -9.007850162627007e-04
E_9_5 n_8_5 n_9_5 9 0 -6.653376064886141e-03
E_10_5 n_9_5 n_10_5 10 0 1.056654125269499e-02
E_11_5 n_10_5 n_11_5 11 0 -6.670155210586015e-01
E_12_5 n_11_5 n_12_5 12 0 -2.772821394453802e-01
E_13_5 n_12_5 n_13_5 13 0 -5.830332618947925e-01
E_14_5 n_13_5 n_14_5 14 0 -2.503103922541612e-01
E_15_5 n_14_5 n_15_5 15 0 -9.218761974217227e-03
E_16_5 n_15_5 0 16 0 2.019795720577794e-01
E_1_6 o_port_6 n_1_6 1 0 3.782723113725073e-03
E_2_6 n_1_6 n_2_6 2 0 1.169872570954231e-03
E_3_6 n_2_6 n_3_6 3 0 -2.482659936376252e-03
E_4_6 n_3_6 n_4_6 4 0 -2.216204584672879e-03
E_5_6 n_4_6 n_5_6 5 0 2.470342396194961e-02
E_6_6 n_5_6 n_6_6 6 0 1.239299087945539e-03
E_7_6 n_6_6 n_7_6 7 0 9.900688533163074e-03
E_8_6 n_7_6 n_8_6 8 0 5.789430740840429e-04
E_9_6 n_8_6 n_9_6 9 0 -3.802256779529972e-04
E_10_6 n_9_6 n_10_6 10 0 5.723967456098091e-04
E_11_6 n_10_6 n_11_6 11 0 -7.005102623815249e-01
E_12_6 n_11_6 n_12_6 12 0 -3.130984857931208e-01
E_13_6 n_12_6 n_13_6 13 0 -3.948446490754904e-01
E_14_6 n_13_6 n_14_6 14 0 -3.864059178770944e-02
E_15_6 n_14_6 n_15_6 15 0 4.274643628535308e-02
E_16_6 n_15_6 0 16 0 2.434393660167368e-02
E_1_7 o_port_7 n_1_7 1 0 3.296426207329062e-03
E_2_7 n_1_7 n_2_7 2 0 1.779234697865395e-04
E_3_7 n_2_7 n_3_7 3 0 -7.605837097258428e-04
E_4_7 n_3_7 n_4_7 4 0 -1.234347349229947e-03
E_5_7 n_4_7 n_5_7 5 0 2.746285225343720e-02
E_6_7 n_5_7 n_6_7 6 0 -4.832197837939339e-03
E_7_7 n_6_7 n_7_7 7 0 9.917593256514423e-03
E_8_7 n_7_7 n_8_7 8 0 -1.291300832824024e-03
E_9_7 n_8_7 n_9_7 9 0 -2.035477499073818e-03
E_10_7 n_9_7 n_10_7 10 0 1.449229664829226e-03
E_11_7 n_10_7 n_11_7 11 0 -7.005344399546884e-01
E_12_7 n_11_7 n_12_7 12 0 -3.125377001970686e-01
E_13_7 n_12_7 n_13_7 13 0 -4.198439801614038e-01
E_14_7 n_13_7 n_14_7 14 0 -5.609742067191154e-02
E_15_7 n_14_7 n_15_7 15 0 4.960098405060250e-02
E_16_7 n_15_7 0 16 0 3.642288658900138e-02
E_1_8 o_port_8 n_1_8 1 0 -3.541641815060281e-03
E_2_8 n_1_8 n_2_8 2 0 5.365162585395655e-04
E_3_8 n_2_8 n_3_8 3 0 2.490783979425149e-03
E_4_8 n_3_8 n_4_8 4 0 5.666450588100891e-03
E_5_8 n_4_8 n_5_8 5 0 2.438785114824793e-02
E_6_8 n_5_8 n_6_8 6 0 -2.113840534421185e-02
E_7_8 n_6_8 n_7_8 7 0 1.635939335906778e-03
E_8_8 n_7_8 n_8_8 8 0 -1.042806430750338e-03
E_9_8 n_8_8 n_9_8 9 0 -3.147509046652397e-03
E_10_8 n_9_8 n_10_8 10 0 2.994959537933673e-03
E_11_8 n_10_8 n_11_8 11 0 -6.976928100703305e-01
E_12_8 n_11_8 n_12_8 12 0 -3.089689471008259e-01
E_13_8 n_12_8 n_13_8 13 0 -4.588635217998708e-01
E_14_8 n_13_8 n_14_8 14 0 -8.863384008945929e-02
E_15_8 n_14_8 n_15_8 15 0 5.302052805486379e-02
E_16_8 n_15_8 0 16 0 6.085638415503630e-02
E_1_9 o_port_9 n_1_9 1 0 -5.755994088873717e-02
E_2_9 n_1_9 n_2_9 2 0 4.630726440177590e-02
E_3_9 n_2_9 n_3_9 3 0 -1.088676681323297e-02
E_4_9 n_3_9 n_4_9 4 0 5.337378672695559e-02
E_5_9 n_4_9 n_5_9 5 0 1.232279795276670e-02
E_6_9 n_5_9 n_6_9 6 0 -3.911656285793219e-02
E_7_9 n_6_9 n_7_9 7 0 -5.572127104931929e-02
E_8_9 n_7_9 n_8_9 8 0 8.798613726620497e-04
E_9_9 n_8_9 n_9_9 9 0 -4.238777306181718e-03
E_10_9 n_9_9 n_10_9 10 0 5.835858325118935e-03
E_11_9 n_10_9 n_11_9 11 0 -6.869244264217205e-01
E_12_9 n_11_9 n_12_9 12 0 -2.977094503195105e-01
E_13_9 n_12_9 n_13_9 13 0 -5.144167515396390e-01
E_14_9 n_13_9 n_14_9 14 0 -1.519635921183419e-01
E_15_9 n_14_9 n_15_9 15 0 3.371787861611897e-02
E_16_9 n_15_9 0 16 0 1.142231682605955e-01
E_1_10 o_port_10 n_1_10 1 0 -9.981527616391839e-02
E_2_10 n_1_10 n_2_10 2 0 8.722643108779138e-02
E_3_10 n_2_10 n_3_10 3 0 -2.574723227657594e-02
E_4_10 n_3_10 n_4_10 4 0 9.021985383003639e-02
E_5_10 n_4_10 n_5_10 5 0 6.918329282085578e-03
E_6_10 n_5_10 n_6_10 6 0 -4.184943028721744e-02
E_7_10 n_6_10 n_7_10 7 0 -9.964279663908115e-02
E_8_10 n_7_10 n_8_10 8 0 1.338776880690035e-03
E_9_10 n_8_10 n_9_10 9 0 -4.673194358009836e-03
E_10_10 n_9_10 n_10_10 10 0 7.443101396773150e-03
E_11_10 n_10_10 n_11_10 11 0 -6.796308713212807e-01
E_12_10 n_11_10 n_12_10 12 0 -2.901990260149322e-01
E_13_10 n_12_10 n_13_10 13 0 -5.411572932302312e-01
E_14_10 n_13_10 n_14_10 14 0 -1.864579215190226e-01
E_15_10 n_14_10 n_15_10 15 0 1.730035674513697e-02
E_16_10 n_15_10 0 16 0 1.451653980828753e-01
E_1_11 o_port_11 n_1_11 1 0 3.493937333149622e-03
E_2_11 n_1_11 n_2_11 2 0 1.692438162603171e-03
E_3_11 n_2_11 n_3_11 3 0 -2.620899694684174e-03
E_4_11 n_3_11 n_4_11 4 0 -2.070473650920029e-03
E_5_11 n_4_11 n_5_11 5 0 2.281751164775397e-02
E_6_11 n_5_11 n_6_11 6 0 2.947078905862197e-03
E_7_11 n_6_11 n_7_11 7 0 9.269907177531775e-03
E_8_11 n_7_11 n_8_11 8 0 6.249845033138544e-04
E_9_11 n_8_11 n_9_11 9 0 -7.310973015015043e-05
E_10_11 n_9_11 n_10_11 10 0 4.705634499299353e-04
E_11_11 n_10_11 n_11_11 11 0 -7.002289952563643e-01
E_12_11 n_11_11 n_12_11 12 0 -3.129429331784082e-01
E_13_11 n_12_11 n_13_11 13 0 -3.802575228484741e-01
E_14_11 n_13_11 n_14_11 14 0 -3.267818641081978e-02
E_15_11 n_14_11 n_15_11 15 0 3.917572782150227e-02
E_16_11 n_15_11 0 16 0 2.026063002880448e-02
E_1_12 o_port_12 n_1_12 1 0 3.655268816457030e-03
E_2_12 n_1_12 n_2_12 2 0 9.718589049391435e-04
E_3_12 n_2_12 n_3_12 3 0 -1.521028472736247e-03
E_4_12 n_3_12 n_4_12 4 0 -1.799817048510538e-03
E_5_12 n_4_12 n_5_12 5 0 2.630170039309811e-02
E_6_12 n_5_12 n_6_12 6 0 -8.606285083416765e-04
E_7_12 n_6_12 n_7_12 7 0 1.045648924081546e-02
E_8_12 n_7_12 n_8_12 8 0 -1.251283326735003e-03
E_9_12 n_8_12 n_9_12 9 0 -1.740709958446773e-03
E_10_12 n_9_12 n_10_12 10 0 1.119772437051827e-03
E_11_12 n_10_12 n_11_12 11 0 -7.008738391952759e-01
E_12_12 n_11_12 n_12_12 12 0 -3.130485493835209e-01
E_13_12 n_12_12 n_13_12 13 0 -4.030583759599013e-01
E_14_12 n_13_12 n_14_12 14 0 -4.682024942512593e-02
E_15_12 n_14_12 n_15_12 15 0 4.608560464520316e-02
E_16_12 n_15_12 0 16 0 2.969577441673515e-02
E_1_13 o_port_13 n_1_13 1 0 1.866664076164926e-03
E_2_13 n_1_13 n_2_13 2 0 -3.172925085688505e-04
E_3_13 n_2_13 n_3_13 3 0 8.801375031398384e-04
E_4_13 n_3_13 n_4_13 4 0 5.010008043091208e-04
E_5_13 n_4_13 n_5_13 5 0 2.767425231095968e-02
E_6_13 n_5_13 n_6_13 6 0 -1.064715449787823e-02
E_7_13 n_6_13 n_7_13 7 0 8.106110163357216e-03
E_8_13 n_7_13 n_8_13 8 0 -2.404981884849985e-03
E_9_13 n_8_13 n_9_13 9 0 -2.956500844823351e-03
E_10_13 n_9_13 n_10_13 10 0 2.218051896234799e-03
E_11_13 n_10_13 n_11_13 11 0 -6.996556291438463e-01
E_12_13 n_11_13 n_12_13 12 0 -3.112719464618665e-01
E_13_13 n_12_13 n_13_13 13 0 -4.341910823386350e-01
E_14_13 n_13_13 n_14_13 14 0 -6.915240903015807e-02
E_15_13 n_14_13 n_15_13 15 0 5.257341775475596e-02
E_16_13 n_15_13 0 16 0 4.596192146757534e-02
E_1_14 o_port_14 n_1_14 1 0 -3.538781964335214e-03
E_2_14 n_1_14 n_2_14 2 0 5.012538616518403e-04
E_3_14 n_2_14 n_3_14 3 0 2.515148382763122e-03
E_4_14 n_3_14 n_4_14 4 0 5.674871993446906e-03
E_5_14 n_4_14 n_5_14 5 0 2.432078092902734e-02
E_6_14 n_5_14 n_6_14 6 0 -2.121065148337387e-02
E_7_14 n_6_14 n_7_14 7 0 1.544586482449595e-03
E_8_14 n_7_14 n_8_14 8 0 -1.004038548002309e-03
E_9_14 n_8_14 n_9_14 9 0 -3.082224654079313e-03
E_10_14 n_9_14 n_10_14 10 0 2.998426964170844e-03
E_11_14 n_10_14 n_11_14 11 0 -6.975740831421913e-01
E_12_14 n_11_14 n_12_14 12 0 -3.088537688883495e-01
E_13_14 n_12_14 n_13_14 13 0 -4.591791365077545e-01
E_14_14 n_13_14 n_14_14 14 0 -8.850401591927326e-02
E_15_14 n_14_14 n_15_14 15 0 5.294598029676453e-02
E_16_14 n_15_14 0 16 0 6.081169293650582e-02
E_1_15 o_port_15 n_1_15 1 0 -6.010329661238822e-03
E_2_15 n_1_15 n_2_15 2 0 1.691578755828316e-03
E_3_15 n_2_15 n_3_15 3 0 2.458202677461108e-03
E_4_15 n_3_15 n_4_15 4 0 7.825533166781806e-03
E_5_15 n_4_15 n_5_15 5 0 2.249044665734140e-02
E_6_15 n_5_15 n_6_15 6 0 -2.341659848561339e-02
E_7_15 n_6_15 n_7_15 7 0 -1.147440191054838e-03
E_8_15 n_7_15 n_8_15 8 0 3.159271338484676e-04
E_9_15 n_8_15 n_9_15 9 0 -2.572364215702283e-03
E_10_15 n_9_15 n_10_15 10 0 3.091152421243792e-03
E_11_15 n_10_15 n_11_15 11 0 -6.966765807311810e-01
E_12_15 n_11_15 n_12_15 12 0 -3.079243416984307e-01
E_13_15 n_12_15 n_13_15 13 0 -4.652775394206986e-01
E_14_15 n_13_15 n_14_15 14 0 -9.235987739413987e-02
E_15_15 n_14_15 n_15_15 15 0 5.178541505467912e-02
E_16_15 n_15_15 0 16 0 6.410346642329579e-02
E_1_16 o_port_16 n_1_16 1 0 2.863978944624711e-03
E_2_16 n_1_16 n_2_16 2 0 2.003883772362641e-03
E_3_16 n_2_16 n_3_16 3 0 -2.919090033111478e-03
E_4_16 n_3_16 n_4_16 4 0 -1.754483001987484e-03
E_5_16 n_4_16 n_5_16 5 0 1.880973493517794e-02
E_6_16 n_5_16 n_6_16 6 0 4.450913542535538e-03
E_7_16 n_6_16 n_7_16 7 0 7.345999066397504e-03
E_8_16 n_7_16 n_8_16 8 0 1.836098669214656e-03
E_9_16 n_8_16 n_9_16 9 0 9.877817098030844e-04
E_10_16 n_9_16 n_10_16 10 0 1.003362721264948e-04
E_11_16 n_10_16 n_11_16 11 0 -6.995875673656350e-01
E_12_16 n_11_16 n_12_16 12 0 -3.126696709561119e-01
E_13_16 n_12_16 n_13_16 13 0 -3.582402355024050e-01
E_14_16 n_13_16 n_14_16 14 0 -2.250111259964380e-02
E_15_16 n_14_16 n_15_16 15 0 3.233618137962699e-02
E_16_16 n_15_16 0 16 0 1.357332329210155e-02
E_1_17 o_port_17 n_1_17 1 0 3.355515234701373e-03
E_2_17 n_1_17 n_2_17 2 0 1.798621372044923e-03
E_3_17 n_2_17 n_3_17 3 0 -2.515864909299462e-03
E_4_17 n_3_17 n_4_17 4 0 -1.956344552276529e-03
E_5_17 n_4_17 n_5_17 5 0 2.253992870393731e-02
E_6_17 n_5_17 n_6_17 6 0 3.070466769742097e-03
E_7_17 n_6_17 n_7_17 7 0 9.409416138436516e-03
E_8_17 n_7_17 n_8_17 8 0 2.717188891643799e-04
E_9_17 n_8_17 n_9_17 9 0 -4.960111093748193e-04
E_10_17 n_9_17 n_10_17 10 0 4.905664487939174e-04
E_11_17 n_10_17 n_11_17 11 0 -7.007121098187837e-01
E_12_17 n_11_17 n_12_17 12 0 -3.133043255225645e-01
E_13_17 n_12_17 n_13_17 13 0 -3.782629986892963e-01
E_14_17 n_13_17 n_14_17 14 0 -3.268802037199352e-02
E_15_17 n_14_17 n_15_17 15 0 3.873282425842093e-02
E_16_17 n_15_17 0 16 0 1.998664515577971e-02
E_1_18 o_port_18 n_1_18 1 0 3.656717532548065e-03
E_2_18 n_1_18 n_2_18 2 0 9.622061810798666e-04
E_3_18 n_2_18 n_3_18 3 0 -1.514553888613324e-03
E_4_18 n_3_18 n_4_18 4 0 -1.797412966085793e-03
E_5_18 n_4_18 n_5_18 5 0 2.628754534802495e-02
E_6_18 n_5_18 n_6_18 6 0 -8.835999139332196e-04
E_7_18 n_6_18 n_7_18 7 0 1.042763622815166e-02
E_8_18 n_7_18 n_8_18 8 0 -1.243145917649693e-03
E_9_18 n_8_18 n_9_18 9 0 -1.721621388822647e-03
E_10_18 n_9_18 n_10_18 10 0 1.120757818631091e-03
E_11_18 n_10_18 n_11_18 11 0 -7.008399409542583e-01
E_12_18 n_11_18 n_12_18 12 0 -3.130159783960531e-01
E_13_18 n_12_18 n_13_18 13 0 -4.031421774548771e-01
E_14_18 n_13_18 n_14_18 14 0 -4.678803257000436e-02
E_15_18 n_14_18 n_15_18 15 0 4.606865487677071e-02
E_16_18 n_15_18 0 16 0 2.968904253041470e-02
E_1_19 o_port_19 n_1_19 1 0 3.298634887775181e-03
E_2_19 n_1_19 n_2_19 2 0 1.613467979006411e-04
E_3_19 n_2_19 n_3_19 3 0 -7.484797070074767e-04
E_4_19 n_3_19 n_4_19 4 0 -1.229886933584279e-03
E_5_19 n_4_19 n_5_19 5 0 2.744249535738177e-02
E_6_19 n_5_19 n_6_19 6 0 -4.872802929277775e-03
E_7_19 n_6_19 n_7_19 7 0 9.877387656916065e-03
E_8_19 n_7_19 n_8_19 8 0 -1.290748386484544e-03
E_9_19 n_8_19 n_9_19 9 0 -2.016127526236478e-03
E_10_19 n_9_19 n_10_19 10 0 1.446378576796745e-03
E_11_19 n_10_19 n_11_19 11 0 -7.005086542980760e-01
E_12_19 n_11_19 n_12_19 12 0 -3.125111761636511e-01
E_13_19 n_12_19 n_13_19 13 0 -4.199094220528585e-01
E_14_19 n_13_19 n_14_19 14 0 -5.605396707816593e-02
E_15_19 n_14_19 n_15_19 15 0 4.957643322213671e-02
E_16_19 n_15_19 0 16 0 3.641393625265018e-02
E_1_20 o_port_20 n_1_20 1 0 3.100150331940416e-03
E_2_20 n_1_20 n_2_20 2 0 7.076331168698324e-06
E_3_20 n_2_20 n_3_20 3 0 -7.658667011462561e-04
E_4_20 n_3_20 n_4_20 4 0 -1.057303828449901e-03
E_5_20 n_4_20 n_5_20 5 0 2.724115605795094e-02
E_6_20 n_5_20 n_6_20 6 0 -5.697231841000849e-03
E_7_20 n_6_20 n_7_20 7 0 9.295705496787446e-03
E_8_20 n_7_20 n_8_20 8 0 -4.703272334137219e-04
E_9_20 n_8_20 n_9_20 9 0 -1.386792708141960e-03
E_10_20 n_9_20 n_10_20 10 0 1.411454228123000e-03
E_11_20 n_10_20 n_11_20 11 0 -6.998341406779429e-01
E_12_20 n_11_20 n_12_20 12 0 -3.119727098506732e-01
E_13_20 n_12_20 n_13_20 13 0 -4.238815803099835e-01
E_14_20 n_13_20 n_14_20 14 0 -5.678146242786600e-02
E_15_20 n_14_20 n_15_20 15 0 4.983138574561413e-02
E_16_20 n_15_20 0 16 0 3.732667191904276e-02
E_1_21 o_port_21 n_1_21 1 0 2.156060933746158e-03
E_2_21 n_1_21 n_2_21 2 0 1.563762849983306e-03
E_3_21 n_2_21 n_3_21 3 0 -2.910220954356238e-03
E_4_21 n_3_21 n_4_21 4 0 -1.338235637838227e-03
E_5_21 n_4_21 n_5_21 5 0 1.360695353649885e-02
E_6_21 n_5_21 n_6_21 6 0 4.215596494899145e-03
E_7_21 n_6_21 n_7_21 7 0 4.382352647617598e-03
E_8_21 n_7_21 n_8_21 8 0 3.208267151860656e-03
E_9_21 n_8_21 n_9_21 9 0 1.983203108775197e-03
E_10_21 n_9_21 n_10_21 10 0 -4.034439692085464e-04
E_11_21 n_10_21 n_11_21 11 0 -6.992973892864923e-01
E_12_21 n_11_21 n_12_21 12 0 -3.128159695408868e-01
E_13_21 n_12_21 n_13_21 13 0 -3.316738564497551e-01
E_14_21 n_13_21 n_14_21 14 0 -1.195075995001355e-02
E_15_21 n_14_21 n_15_21 15 0 2.375803083633375e-02
E_16_21 n_15_21 0 16 0 6.740693684076648e-03
E_1_22 o_port_22 n_1_22 1 0 2.859981574898258e-03
E_2_22 n_1_22 n_2_22 2 0 2.005910932497572e-03
E_3_22 n_2_22 n_3_22 3 0 -2.920930298740475e-03
E_4_22 n_3_22 n_4_22 4 0 -1.752553986200639e-03
E_5_22 n_4_22 n_5_22 5 0 1.880150611979116e-02
E_6_22 n_5_22 n_6_22 6 0 4.455355951479542e-03
E_7_22 n_6_22 n_7_22 7 0 7.349572085202325e-03
E_8_22 n_7_22 n_8_22 8 0 1.840884691535560e-03
E_9_22 n_8_22 n_9_22 9 0 9.836697680193421e-04
E_10_22 n_9_22 n_10_22 10 0 1.040944571398619e-04
E_11_22 n_10_22 n_11_22 11 0 -6.995738917867864e-01
E_12_22 n_11_22 n_12_22 12 0 -3.126584752912444e-01
E_13_22 n_12_22 n_13_22 13 0 -3.583426861185536e-01
E_14_22 n_13_22 n_14_22 14 0 -2.249835459313740e-02
E_15_22 n_14_22 n_15_22 15 0 3.232640124736212e-02
E_16_22 n_15_22 0 16 0 1.356134494270922e-02
E_1_23 o_port_23 n_1_23 1 0 3.492727216525965e-03
E_2_23 n_1_23 n_2_23 2 0 1.698127763507987e-03
E_3_23 n_2_23 n_3_23 3 0 -2.629753374508138e-03
E_4_23 n_3_23 n_4_23 4 0 -2.074481272690831e-03
E_5_23 n_4_23 n_5_23 5 0 2.281585220897867e-02
E_6_23 n_5_23 n_6_23 6 0 2.967258512232701e-03
E_7_23 n_6_23 n_7_23 7 0 9.280500204415225e-03
E_8_23 n_7_23 n_8_23 8 0 6.475327005882603e-04
E_9_23 n_8_23 n_9_23 9 0 -6.870093536326394e-05
E_10_23 n_9_23 n_10_23 10 0 4.755567607003456e-04
E_11_23 n_10_23 n_11_23 11 0 -7.002088960057639e-01
E_12_23 n_11_23 n_12_23 12 0 -3.129281675511282e-01
E_13_23 n_12_23 n_13_23 13 0 -3.803137033684944e-01
E_14_23 n_13_23 n_14_23 14 0 -3.268269853571944e-02
E_15_23 n_14_23 n_15_23 15 0 3.917306043713124e-02
E_16_23 n_15_23 0 16 0 2.025658035858471e-02
E_1_24 o_port_24 n_1_24 1 0 3.778682191462615e-03
E_2_24 n_1_24 n_2_24 2 0 1.174166188183307e-03
E_3_24 n_2_24 n_3_24 3 0 -2.478916581697674e-03
E_4_24 n_3_24 n_4_24 4 0 -2.213501187055003e-03
E_5_24 n_4_24 n_5_24 5 0 2.470625002377015e-02
E_6_24 n_5_24 n_6_24 6 0 1.242672317754406e-03
E_7_24 n_6_24 n_7_24 7 0 9.922243524434160e-03
E_8_24 n_7_24 n_8_24 8 0 5.514308429895743e-04
E_9_24 n_8_24 n_9_24 9 0 -4.103653016737929e-04
E_10_24 n_9_24 n_10_24 10 0 5.726486802858578e-04
E_11_24 n_10_24 n_11_24 11 0 -7.005381029883534e-01
E_12_24 n_11_24 n_12_24 12 0 -3.131285995804843e-01
E_13_24 n_12_24 n_13_24 13 0 -3.947593940199447e-01
E_14_24 n_13_24 n_14_24 14 0 -3.866992453961476e-02
E_15_24 n_14_24 n_15_24 15 0 4.274905329976464e-02
E_16_24 n_15_24 0 16 0 2.434286554084665e-02
E_1_25 o_port_25 n_1_25 1 0 3.806018619391310e-03
E_2_25 n_1_25 n_2_25 2 0 9.892643707291593e-04
E_3_25 n_2_25 n_3_25 3 0 -2.698416308492158e-03
E_4_25 n_3_25 n_4_25 4 0 -2.284649206642009e-03
E_5_25 n_4_25 n_5_25 5 0 2.475152021866077e-02
E_6_25 n_5_25 n_6_25 6 0 8.817611050596919e-04
E_7_25 n_6_25 n_7_25 7 0 9.671068646983812e-03
E_8_25 n_7_25 n_8_25 8 0 1.415150110788195e-03
E_9_25 n_8_25 n_9_25 9 0 1.704345563385556e-04
E_10_25 n_9_25 n_10_25 10 0 4.596165262091049e-04
E_11_25 n_10_25 n_11_25 11 0 -6.999702467200857e-01
E_12_25 n_11_25 n_12_25 12 0 -3.128018533286299e-01
E_13_25 n_12_25 n_13_25 13 0 -3.985870427763298e-01
E_14_25 n_13_25 n_14_25 14 0 -3.872905438835327e-02
E_15_25 n_14_25 n_15_25 15 0 4.306103325670808e-02
E_16_25 n_15_25 0 16 0 2.467861979844466e-02
I_ex1 0 port_1 AC 1 sin(0 1 1K)
.tran 0.1ms 10ms
.AC DEC  100  0.001 100
.options accurate=0 post=1
.END
